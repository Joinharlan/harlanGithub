# Keil uVision project THM3100_HID.uvprojx, settings and files
target THM3100_MNT (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.1.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(10000000) ESEL ELITTLE
  output: THM3100_MNT +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ../Obj/ZhongF_HM5-T1.04_20191023_00000001.bin  ../Obj/@L.axf
  c flags: Optim=2 OneElfS=1 wLevel=1
  c define: __CHECK_DEVICE_DEFINES, HID=1,LINUX
  c misc: --wchar32
  c include: ..\src\API\inc;..\src\API\src;..\src\App\inc;..\src\App\src;..\src\EmvKernel\inc;..\src\EmvKernel\src;..\src\LIB\inc;..\src\polarssl-1.0.0\app\inc;..\src\polarssl-1.0.0\app\src;..\src\polarssl-1.0.0\include\polarssl;..\src\polarssl-1.0.0\library;..\src\Protocol\inc;..\src\Protocol\src;..\src\ProtocolAssis\inc;..\src\ProtocolAssis\src;..\src\qpboc\inc;..\src\qpboc\src;..\src\test_app;..\src\TMS\inc;..\src\TMS\src
  library: MicroLIB
  memory RVCT4: ROM 0x100 size 0xa0000
  memory RVCT9: RAM 0x20000400 size 0xfc00
  scatter file: ..\src\App\src\scat.sct
  group APP
    ../src/App/src/: main.c startup_MPS_CM0.s EMVAidCapk.c globalvar.c
  group Protocol
    ../src/Protocol/src/: EmvRsa.c P8583_Assist.c P8583_Error.c P8583_Proc.c P8583_Trade.c TradeAssistFun.c
  group ProtocolAssis
    ../src/ProtocolAssis/src/: ICCardAppFun.c LoginFun.c menu.c
  group LIB
    ../src/LIB/: emvcore.lib dll.lib
  group EmvKernel
    ../src/EmvKernel/src/: emvfile.c emvif.c emvinsertcard.c emvport.c emvproc.c emvvar.c
  group API
    ../src/API/src/: AppApi.c dev_math.c flash_oper.c var.c
  group qpboc
    ../src/qpboc/src/: qpbocport.c qpbocTran.c
  group app_test
    ../src/test_app/: ic_test_app.c uart_test_app.c U8_UNICODE.c
  group TMS
    ../src/TMS/src/: md5.c TMS.c SHA4.c
